# IAR project projworkspace.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F103C8 ST STM32F103C8
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F10X_MD; VECT_TAB_SRAM
  ICCARM.CCIncludePath2: ..\app\inc; ..\cmsis\DeviceSupport; ..\freertos\include; ..\freertos\portable\iar; ..\stm_periph_lib\inc; ..\userlib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\app\inc
  OBJCOPY.OOCOutputFile: projworkspace.bin
  ILINK.IlinkOutputFile: projworkspace.out
  ILINK.IlinkIcfFile: stm32f10x_ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_STDPERIPH_DRIVER; STM32F10X_MD; USE_DMP; MPL_LOG_NDEBUG=1; EMPL; MPU9250
  ICCARM.CCIncludePath2: ..\app\inc; ..\cmsis\DeviceSupport; ..\freertos\include; ..\freertos\portable\iar; ..\stm_periph_lib\inc; ..\userlib; ..\userlib\motion_driver\driver\eMPL; ..\userlib\motion_driver\driver\include; ..\userlib\motion_driver\eMPL-hal; ..\userlib\motion_driver\mllite; ..\userlib\motion_driver\mpl
  ICCARM.CCOptLevel: 3
  ILINK.IlinkIcfFile: E:\cortex-m3\gnustm32\iarproj\stm32f10x_flash.icf
  ILINK.IlinkAdditionalLibs: ..\userlib\motion_driver\mpl\libmpllib.a
  group app
    ../app/inc/: datapack.c
    ../app/src/: main.c stm32f10x_it.c
  group cmsis
    ./: startup_stm32f10x_md.s
    ../cmsis/DeviceSupport/: system_stm32f10x.c
  group freertos
    ../freertos/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../freertos/portable/: heap_4.c
    ../freertos/portable/iar/: port.c portasm.s
  group stm_periph_lib
    ../stm_periph_lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group userlib
    ../userlib/: bmp085.c i2c.c led.c serial.c servo.c
  group userlib/mpu9255
    ../userlib/motion_driver/mllite/: data_builder.c hal_outputs.c message_layer.c ml_math_func.c mlmath.c mpl.c results_holder.c start_manager.c storage_manager.c
    ../userlib/motion_driver/eMPL-hal/: eMPL_outputs.c
    ../userlib/motion_driver/driver/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
